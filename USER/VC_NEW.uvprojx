# Keil uVision project VC_NEW.uvprojx, settings and files
target VC_NEW (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: VC_NEW +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\SYSTEM;..\HARDWARE;..\HARDWARE\VI5310X;..\HARDWARE\User_Interface;..\HARDWARE\FATFS\src;..\HARDWARE\FATFS\exfuns;..\HARDWARE\FATFS\src\option;..\HARDWARE\TEXT;..\HARDWARE\PICTURE;..\HARDWARE\MPU6050;..\HARDWARE\arithmetic;..\HARDWARE\BH1750;..\HARDWARE\ADC;..\HARDWARE\POWER
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/: key.c led.c TFT.c w25q64.c SD.c malloc.c HC_SR04.c
    ../HARDWARE/User_Interface/: InterFace.c SD_IFace.c Modules_IFace.c
    ../HARDWARE/MPU6050/: mpu6050.c
    ../HARDWARE/BH1750/: BH1750.c
    ../HARDWARE/timer/: PWMOUT.c
    ../HARDWARE/ADC/: ADC.c
    ../HARDWARE/POWER/: POWER.C
  group SYSTEM
    ../SYSTEM/: delay.c sys.c usart.c
    ../HARDWARE/arithmetic/: Arithmetic.c
  group vl53l0X
    ../HARDWARE/VI5310X/: vl53l0x.c vl53l0x_api.c vl53l0x_api_calibration.c vl53l0x_api_core.c vl53l0x_api_ranging.c vl53l0x_api_strings.c vl53l0x_cali.c vl53l0x_gen.c vl53l0x_i2c.c vl53l0x_it.c vl53l0x_platform.c
  group FATFS
    ../HARDWARE/FATFS/src/: User_FAT.c diskio.c ff.c
    ../HARDWARE/FATFS/src/option/: cc936.c
    ../HARDWARE/FATFS/exfuns/: exfuns.c fattester.c
  group TEXT
    ../HARDWARE/TEXT/: fontupd.c text.c
  group PICTURE
    ../HARDWARE/PICTURE/: bmp.c gif.c piclib.c tjpgd.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_adc.c
  group README
    ../: README.TXT
